## src/drivers/coprocessor_uart/Kconfig
```kconfig
menuconfig DRIVERS_COPROCESSOR_UART
	bool "coprocessor_uart"
	default n
	---help---
		Enable support for coprocessor uart
```
